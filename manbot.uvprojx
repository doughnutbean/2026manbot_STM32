# Keil uVision project manbot.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: manbot
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD,RTE_CMSIS_RTOS2_RTX5,__ARM_ARCH_7M__=1
  c include: .;.\Core\Inc;.\App\Inc;.\Drivers\CMSIS\CoreSupport;.\Drivers\CMSIS\Core\Include;.\Drivers\CMSIS\DeviceSupport\ST\STM32F10x;.\Drivers\STM32F10x_StdPeriph_Driver\inc;.\Drivers\RTX5\Include;.\Drivers\RTX5\RTX\Include;.\Drivers\RTX5\Config
  asm define: STM32F10X_HD,RTE_CMSIS_RTOS2_RTX5,__ARM_ARCH_7M__=1
  asm include: as above
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  link libs: RTX_CM3.lib
  group Core
    ./Core/Src/: main.c
    ./Drivers/CMSIS/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group Startup
    ./Drivers/CMSIS/DeviceSupport/ST/STM32F10x/: startup_stm32f10x_hd.s
  group App
    ./App/Src/: mb_app.c mb_tasks.c mb_display_ili9341.c
  group StdPeriph
    ./Drivers/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_rcc.c stm32f10x_gpio.c stm32f10x_usart.c stm32f10x_tim.c stm32f10x_i2c.c stm32f10x_spi.c stm32f10x_fsmc.c
  group RTX5
    ./Drivers/RTX5/Config/: RTX_Config.c
    ./Drivers/RTX5/Source/: rtx_lib.c
    ./Drivers/RTX5/Lib/: RTX_CM3.lib
